options:
  parameters:
    author: root
    generate_options: qt_gui
    id: Audio_test
    output_language: python
    title: Audio Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '46000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:2,1
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: audio in
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
