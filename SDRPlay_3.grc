options:
  parameters:
    generate_options: qt_gui
    id: SDRPlay
    output_language: python
    title: SDRPlay
  states: {}

blocks:
- name: beaken_gain
  id: variable_qtgui_range
  parameters:
    label: beaken_gane
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.3'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: samp_rate_base_band
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: beacon ofset
    orient: Qt.Horizontal
    start: '-20000'
    step: '1'
    stop: '20000'
    value: '1000'
  states: {state: disabled}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: samp_rate_base_band
    tau: '75e-6'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-23000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_base_band
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:2,1
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rf_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: beaken_gain
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '25'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/25/64
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '26000'
    decim: '2'
    gain: '1'
    samp_rate: '480000'
    type: fir_filter_ccf
    width: 480000/2/64
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: sdrplay
    bb_gain0: '50'
    freq0: 435.1e6
    gain0: '50'
    gain_mode0: 'True'
    if_gain0: '50'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate_base_band
    fc: 435.1e6
    fftsize: '1024'
    grid: 'True'
    name: sdr after disimation
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-30'
    ymin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_base_band
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_base_band
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rpitx_rpitx_source_0
  id: rpitx_rpitx_source
  parameters:
    carrier_freq: 145.950e6
    samp_rate: samp_rate_base_band
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'True'
    balance0: '0'
    center_freq0: 435.10e6
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    dev: driver=sdrplay
    devname: sdrplay
    overall_gain0: '42'
    samp_rate: samp_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'False'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    type: fc32
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_2, '0', analog_nbfm_tx_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', rpitx_rpitx_source_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_null_source_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0_0, '0', rpitx_rpitx_source_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [soapy_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
