options:
  parameters:
    author: root
    generate_options: qt_gui
    id: test_rpitx
    output_language: python
    title: Test Rpitx
  states: {}

blocks:
- name: low_pass_filter_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lpf_cutoff_freq
  id: variable
  parameters:
    value: '30000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '435100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*2
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1248000'
  states: {}
- name: sdrplay_rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tran_tx_freq
  id: variable
  parameters:
    value: '145960000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: sdrplay rf gain
    orient: Qt.Horizontal
    start: '-30'
    step: '1'
    stop: '30'
    value: '5'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: lpf rf gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff_freq
    decim: '1'
    gain: variable_qtgui_range_0
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/32
    win: firdes.WIN_HAMMING
  states: {}
- name: rpitx_rpitx_source_0
  id: rpitx_rpitx_source
  parameters:
    carrier_freq: tran_tx_freq
    samp_rate: samp_rate
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    args: driver=sdrplay
    balance0: '0'
    center_freq0: rx_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=sdrplay
    devname: custom
    overall_gain0: variable_qtgui_range_0
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [low_pass_filter_0, '0', rpitx_rpitx_source_0, '0']
- [soapy_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
