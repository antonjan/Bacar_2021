options:
  parameters:
    author: root
    generate_options: no_gui
    id: africube_v1_with_beacon_xml_rpc
    output_language: python
    run_options: run
    title: Test Rpitx
  states: {}

blocks:
- name: Beacom_mixer_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Beacom_overall_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Beacon_mod_gain
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: LPF_rf_gain_0
  id: variable
  parameters:
    value: '9'
  states: {}
- name: SDR_rf_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: beacon_Preemphasis
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: beacon_deviation
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: beacon_int_phase
  id: variable
  parameters:
    value: '0'
  states: {}
- name: beacon_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: beacon_offset_freq
  id: variable
  parameters:
    value: '-24000'
  states: {}
- name: beacon_tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: low_pass_filter_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lpf_cutoff_freq
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '435100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48000*2
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '1248000'
  states: {}
- name: sdrplay_rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tran_tx_freq
  id: variable
  parameters:
    value: '145970000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: sdrplay rf gain
    orient: Qt.Horizontal
    start: '-30'
    step: '1'
    stop: '30'
    value: '9'
  states: {state: disabled}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: lpf rf gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {state: disabled}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Beacon mixer Gain
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '2'
    value: '0.8'
  states: {state: disabled}
- name: variable_qtgui_range_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Beacon mod gain Gain
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '2'
    value: '0.8'
  states: {state: disabled}
- name: variable_qtgui_range_0_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Beacon Gain
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '2'
    value: '0.088'
  states: {state: disabled}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: beacon_Preemphasis
    max_dev: beacon_deviation
    quad_rate: samp_rate
    tau: beacon_tau
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Beacom_mixer_gain
    freq: beacon_offset_freq
    offset: beacon_offset
    phase: beacon_int_phase
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:2,1
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '30000'
    low_cutoff_freq: '21000'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/32
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Beacon_mod_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Beacom_overall_gain
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/africube_software/test_audio.wav
    repeat: 'True'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_cutoff_freq
    decim: '1'
    gain: LPF_rf_gain_0
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/32
    win: firdes.WIN_HAMMING
  states: {}
- name: rpitx_rpitx_source_0
  id: rpitx_rpitx_source
  parameters:
    carrier_freq: tran_tx_freq
    samp_rate: samp_rate
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    args: driver=sdrplay
    balance0: '0'
    center_freq0: rx_freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=sdrplay
    devname: custom
    overall_gain0: SDR_rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8008'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://localhost:50241
    timeout: '100'
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', rpitx_rpitx_source_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '1']
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
